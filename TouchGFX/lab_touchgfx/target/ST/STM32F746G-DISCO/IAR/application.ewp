# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429NI ST STM32F429NI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: ST; STM32F756xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32746G_DISCOVERY; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\..\..\gui\include; ..\..\..\..\target\include; ..\..\..\..\platform\os; ..\..\..\..\generated\fonts\include; ..\..\..\..\generated\images\include; ..\..\..\..\generated\texts\include; ..\..\..\..\generated\gui_generated\include; ..\..\..\..\..\touchgfx_evo\touchgfx_evo; $_TOUCHGFX_HOME_$\touchgfx\framework\include; $_TOUCHGFX_HOME_$\touchgfx\framework\include\platform\core\arm\cortex-m\CMSIS; $_TOUCHGFX_HOME_$\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx; $_TOUCHGFX_HOME_$\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\CMSIS; $_TOUCHGFX_HOME_$\touchgfx\framework\include\platform\hal\ST\mcu\stm32f7xx\STM32F7xx_HAL_Driver; $_TOUCHGFX_HOME_$\touchgfx\board\ST\STM32F746G-DISCO\include; $_TOUCHGFX_HOME_$\touchgfx\board\ST\STM32F746G-DISCO\include\vendor; $_TOUCHGFX_HOME_$\touchgfx\board\ST\STM32F746G-DISCO\source\vendor\STM32746G-Discovery; $_TOUCHGFX_HOME_$\touchgfx\os\FreeRTOS8.2.0\Source\include; $_TOUCHGFX_HOME_$\touchgfx\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  prebuild: assets.bat ../../../..
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkAdditionalLibs: $_TOUCHGFX_HOME_$\touchgfx\lib\core\cortex_m7\IAR\touchgfx_core.a; C:\Data\Build\GitHub\Lab\TouchGFX\touchgfx_evo\target\ST\STM32F746G-DISCO\IAR\Debug\Exe\library.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../../../generated/fonts/src/: ApplicationFontProvider.cpp Font_RobotoCondensed_Regular_12_4bpp.cpp FontGetters.cpp Kerning_RobotoCondensed_Regular_12_4bpp.cpp Table_RobotoCondensed_Regular_12_4bpp.cpp
  group Application/generated/images
    ../../../../generated/images/src/: base_mcu_load_background.cpp BitmapDatabase.cpp fat_slider_background_282x45.cpp fat_slider_filled_282x45.cpp fat_slider_knob_37x29.cpp material_wallpaper_gyp1_480x272.cpp ok_112x56.cpp ok_p_112x56.cpp
  group Application/generated/texts
    ../../../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../../../gui/src/common/: BasePresenter.cpp FrontendApplication.cpp McuLoadSlider.cpp
  group Application/gui/model
    ../../../../gui/src/model/: Model.cpp
  group Application/gui/template_screen
    ../../../../gui/src/template_screen/: TemplatePresenter.cpp TemplateView.cpp
  group Application/gui/widget
    ../../../../gui/src/widget/: GaussianFrame.cpp
  group Application/main
    ../../../: main.cpp
  group Board/STM32F746G-DISCO
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
  group Board/STM32F746G-DISCO/BSP
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/bsp/: STM32F746GTouchController.cpp STM32F7Instrumentation.cpp
  group Board/STM32F746G-DISCO/Vendor
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/Components/ft5336/: ft5336.c
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/board/ST/STM32F746G-DISCO/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group MCU
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group MCU/stm32f7xx
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/IAR/: startup_stm32f746xx.s
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/STM32F7xx_HAL_Driver/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/CMSIS/: system_stm32f7xx.c
  group OS
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
    ../../../../../../../../../../touchgfx/4.8.0/touchgfx/os/FreeRTOS8.2.0/Source/portable/IAR/ST_CM7/: port.c portasm.s
